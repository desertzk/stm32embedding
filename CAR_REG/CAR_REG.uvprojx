# Keil uVision project CAR_REG.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CAR_REG +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: .\Start;.\User;.\Dri;.\Int;.\Com;.\App;.\Mid\FreeRTOS;.\Mid\FreeRTOS\include;.\Mid\FreeRTOS\Portable;.\Int\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User
    ./User/: main.c
  group Dri
    ./Dri/: Dri_TIM.c Dri_USART1.c Dri_I2C.c Dri_ADC.c Dri_SPI.c Dri_USART2.c
  group Int
    ./Int/: Int_TB6612.c Int_Encoder.c Int_MPU6050.c
    ./Int/OLED/: oled.c
  group Com
    ./Com/: Com_Filter.c Com_PID.c
  group App
    ./App/: App_Car.c App_Task.c
  group Mid/FreerRTOS
    ./Mid/FreeRTOS/: FreeRTOSConfig.h
  group Mid/FreeRTOS/Source
    ./Mid/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Mid/FreeRTOS/Portable
    ./Mid/FreeRTOS/Portable/: heap_4.c port.c
